# Repository wayoffthecoast/reference-PDB-files (continued)

## KiCad design Pi-Hat/Pi-Hat.kicad_pcb

Parts:
C1, C2, C3: 1uF; C_0805_HS
D1, D2: LED; LED_0603
H1, H2, H3, H4: 3mm_Mounting_Hole; MH_plated
J1: raspberrypi_hat:OX40HAT; Connector_PinSocket_2.54mm
J2: Header_10Pin; 10Pin_Header
J3, J4, J5: Header_8Pin; 8Pin_Header
J6: RJ14; 609-5080-ND
J7: 2Screw_Term; 277-1667-ND
Q3, Q4: 2N7002
Q5: BSS123; 2N7002
R1, R2: 510; R_805_HS
R3, R6: DNP; R_805_HS
R4, R5, R10, R12: 10k; R_805_HS
U1: MAX481; SO-8

Connections:
/A: J6.3 (R1), J7.1, R3.1, R5.1, U1.6 (A)
/B: J6.4 (T1), J7.2, R3.2, R10.1, U1.7 (B)
/CE0: J1.24, J2.5
/CE1: J1.26, J2.4
/MISO: J1.21, J2.7
/MOSI: J1.19, J2.8
/P0: J1.11, J3.1
/P1: J1.12, J3.2
/P2: J1.13, J3.3
/P3: J1.15, J3.4
/P3V3: C1.1, C2.1, J1.1, J1.17, J2.3, J5.5, J5.6, J5.7, J5.8, R1.1, R2.1, R5.2, R12.2, U1.8 (Vcc)
/P4: J1.16, J3.5
/P5: J1.18, J3.6
/P5V: C3.1, J1.2, J1.4, J2.2, J5.1, J5.2, J5.3, J5.4
/P6: J1.22, J3.7
/P7: J1.7, J3.8
/RXD: J1.10, Q4.1 (G), U1.1
/SCL: J1.5, J2.9
/SCLK: J1.23, J2.6
/SDA: J1.3, J2.10
/TXD: J1.8, Q3.1 (G), R4.1, U1.4
/TXD_2: J1.29, R6.1
unnamed: D1.1, Q3.2 (S), R1.2
unnamed: D2.1, Q4.2 (S), R2.2
unnamed: Q5.1 (G), R4.2, R6.2
unnamed: Q5.3 (D), R12.1, U1.2, U1.3

Notes on the sheet:
5V Powered HAT Protection
This is the recommended 5V rail protection for a HAT with power going to the Pi. See https://github.com/raspberrypi/hats/blob/master/designguide.md#back-powering-the-pi-via-the-j8-gpio-header
Mounting Holes
40-Pin HAT Connector
This is based on the official Raspberry Pi spec to be able to call an extension board a HAT. https://github.com/raspberrypi/hats/blob/master/designguide.md

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
Board: 2 copper layers, 65.0 x 56.0 mm, 28 parts (1 on the bottom side), 27 nets.

## Code that names these connections

File Motor_Board | Software/PwmBlink/PwmBlink.ino:

// Simple test of TLC5940
// Measure the shift register length
// then flash the PWM outputs on and off

#define SOUT 9
#define SIN 8
#define SCLK 10
#define XLAT 11
#define GSCLK 12

#define SRLEN 192
#define MAX_SHIFT (SRLEN*4)

#define PWM_CYCLE 4096

static  uint16_t len = 0;

void setup() {
  // put your setup code here, to run once:
  pinMode( SOUT, OUTPUT);
  pinMode( SCLK, OUTPUT);
  pinMode( XLAT, OUTPUT);
  pinMode( GSCLK, OUTPUT);

  digitalWrite( SOUT, LOW);
  digitalWrite( SCLK, LOW);
  digitalWrite( XLAT, LOW);

  Serial.begin( 9600);

  // shift out zeroes, then shift a 1 and measure SR length
  Serial.println("filling SR");
  digitalWrite( SOUT, LOW);
  for( uint16_t i=0; i<MAX_SHIFT; i++) {
    digitalWrite( SCLK, HIGH);
    digitalWrite( SCLK, LOW);
  }

  
  digitalWrite( SOUT, HIGH);
  Serial.println( "measuring SR");
  for( uint16_t i=0; i<MAX_SHIFT; i++) {
     digitalWrite( SCLK, HIGH);
     digitalWrite( SCLK, LOW);
     ++len;
     if( digitalRead( SIN) == HIGH) {
      Serial.print("SR length = ");
      Serial.println(len);
      break;
     }
  }

}

void loop() {
  // now send alternate all 1s and all 0s to the PWM
  // then pulse XLAT
  Serial.println("Set ones");
  
  digitalWrite( SOUT, HIGH);
  for( uint16_t i=0; i<len; i++) {
     digitalWrite( SCLK, HIGH);
     digitalWrite( SCLK, LOW);
  }

  digitalWrite( XLAT, HIGH);
  digitalWrite( XLAT, LOW);

  // pulse the PWM clock
  for( uint16_t i=0; i<PWM_CYCLE; i++) {
    digitalWrite( GSCLK, HIGH);
    digitalWrite( GSCLK, LOW);
  }
  

  delay( 500);
  
  Serial.println("Set zeroes");
  digitalWrite( SOUT, LOW);
  for( uint16_t i=0; i<len; i++) {
     digitalWrite( SCLK, HIGH);
     digitalWrite( SCLK, LOW);
  }
  digitalWrite( XLAT, HIGH);
  digitalWrite( XLAT, LOW);

  // pulse the PWM clock
  for( uint16_t i=0; i<PWM_CYCLE; i++) {
    digitalWrite( GSCLK, HIGH);
    digitalWrite( GSCLK, LOW);
  }

  delay( 500);
}
