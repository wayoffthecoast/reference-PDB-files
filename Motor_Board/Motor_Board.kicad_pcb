# Repository wayoffthecoast/reference-PDB-files (continued)

## KiCad design ADC/ADC.kicad_pcb

Board: 4 copper layers, 33.0 x 66.0 mm, 98 parts (0 on the bottom side), 73 nets.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24: .1uF; C_0402
IC1: 74HC4067; 74HC_HTC4067
P1, P2: CONNX25; 25_pin_10in
R1, R4, R5, R8, R9, R12, R13, R16, R17, R20, R21, R24, R25, R28, R29, R32, R33, R36, R37, R40, R41, R44, R45, R48, R49, R52, R53, R56, R57, R60, R61, R64, R65: 10k; R_0402
R2, R3, R6, R7, R10, R11, R14, R15, R18, R19, R22, R23, R26, R27, R30, R31, R34, R35, R38, R39, R42, R43, R46, R47, R50, R51, R54, R55, R58, R59, R62, R63: OMIT; R_0402
U1: TLV1117LV33DCYR; TLV1117
U2: MCP6001
U3, U4, U5, U6: MCP6004

Connections:
+3V3: C1.1, C3.1, C4.1, C5.1, C10.1, C15.1, C20.1, IC1.24, P2.20, U1.2, U1.4, U2.5, U3.4, U4.4, U5.4, U6.4
+5V: C2.1, P2.23, P2.24, U1.3
/MCP6004_1/OPOUT1: C6.1, IC1.9, R5.2
/MCP6004_1/OPOUT2: C7.1, IC1.8, R9.2
/MCP6004_1/OPOUT3: C8.1, IC1.7, R13.2
/MCP6004_1/OPOUT4: C9.1, IC1.6, R17.2
/MCP6004_2/OPOUT1: C11.1, IC1.5, R21.2
/MCP6004_2/OPOUT2: C12.1, IC1.4, R25.2
/MCP6004_2/OPOUT3: C13.1, IC1.3, R29.2
/MCP6004_2/OPOUT4: C14.1, IC1.2, R33.2
/MCP6004_3/OPOUT1: C16.1, IC1.23, R37.2
/MCP6004_3/OPOUT2: C17.1, IC1.22, R41.2
/MCP6004_3/OPOUT3: C18.1, IC1.21, R45.2
/MCP6004_3/OPOUT4: C19.1, IC1.20, R49.2
/MCP6004_4/OPOUT1: C21.1, IC1.19, R53.2
/MCP6004_4/OPOUT2: C22.1, IC1.18, R57.2
/MCP6004_4/OPOUT3: C23.1, IC1.17, R61.2
/MCP6004_4/OPOUT4: C24.1, IC1.16, R65.2
/M_0: IC1.10, P1.20, R1.2
/M_1: IC1.11, P1.21
/M_2: IC1.14, P1.22
/M_3: IC1.13, P1.23
/M_OUT: P2.21, U2.1, U2.4
/OPIN_1: P1.2, R2.2, U3.3
/OPIN_2: P1.4, R6.2, U3.5
/OPIN_3: P2.4, R10.2, U3.10
/OPIN_4: P2.2, R14.2, U3.12
/OPIN_5: P1.6, R18.2, U4.3
/OPIN_6: P1.8, R22.2, U4.5
/OPIN_7: P2.8, R26.2, U4.10
/OPIN_8: P2.6, R30.2, U4.12
/OPIN_9: P1.11, R34.2, U5.3
/OPIN_10: P1.13, R38.2, U5.5
/OPIN_11: P2.13, R42.2, U5.10
/OPIN_12: P2.11, R46.2, U5.12
/OPIN_13: P1.15, R50.2, U6.3
/OPIN_14: P1.17, R54.2, U6.5
/OPIN_15: P2.17, R58.2, U6.10
/OPIN_16: P2.15, R62.2, U6.12
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, IC1.12, IC1.15, P1.1, P1.3, P1.5, P1.7, P1.9, P1.10, P1.12, P1.14, P1.16, P1.18, P1.19, P1.25, P2.1, P2.3, P2.5, P2.7, P2.9, P2.10, P2.12, P2.14, P2.16, P2.18, P2.19, P2.25, R1.1, R2.1, R3.2, R6.1, R7.1, R10.1, R11.1, R14.1, R15.1, R18.1, R19.2, R22.1, R23.1, R26.1, R27.1, R30.1, R31.1, R34.1, R35.2, R38.1, R39.1, R42.1, R43.1, R46.1, R47.1, R50.1, R51.2, R54.1, R55.1, R58.1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
unnamed: IC1.1, U2.3
unnamed: R3.1, R4.1, U3.2
unnamed: R4.2, R5.1, U3.1
unnamed: R7.2, R8.1, U3.6
unnamed: R8.2, R9.1, U3.7
unnamed: R11.2, R12.1, U3.9
unnamed: R12.2, R13.1, U3.8
unnamed: R15.2, R16.1, U3.13
unnamed: R16.2, R17.1, U3.14
unnamed: R19.1, R20.1, U4.2
unnamed: R20.2, R21.1, U4.1
unnamed: R23.2, R24.1, U4.6
unnamed: R24.2, R25.1, U4.7
unnamed: R27.2, R28.1, U4.9
unnamed: R28.2, R29.1, U4.8
unnamed: R31.2, R32.1, U4.13
unnamed: R32.2, R33.1, U4.14
unnamed: R35.1, R36.1, U5.2
unnamed: R36.2, R37.1, U5.1
unnamed: R39.2, R40.1, U5.6
unnamed: R40.2, R41.1, U5.7
unnamed: R43.2, R44.1, U5.9
unnamed: R44.2, R45.1, U5.8
unnamed: R47.2, R48.1, U5.13
unnamed: R48.2, R49.1, U5.14
unnamed: R51.1, R52.1, U6.2
unnamed: R52.2, R53.1, U6.1
unnamed: R55.2, R56.1, U6.6
unnamed: R56.2, R57.1, U6.7
unnamed: R59.2, R60.1, U6.9
unnamed: R60.2, R61.1, U6.8
unnamed: R63.2, R64.1, U6.13
unnamed: R64.2, R65.1, U6.14

File ADC/ADC_BOM_single_IC1_IS_WRONG?_.csv:

Reference, Comment, Footprint, Datasheet, Supplier Num, Supplier Name,
U1,TLV1117LV33DCYR,ADC:TLV1117,,296-28778-1-ND,Texas Instruments,"
"
C4,.1uF,Capacitors_SMD:C_0402,,,,
C2,.1uF,Capacitors_SMD:C_0402,,,,
P1,CONNX25,mods:25_pin_10in,,ED10025-ND,Mill-Max Manufacturing Corp.,"
"
P2,CONNX25,mods:25_pin_10in,,ED10025-ND,Mill-Max Manufacturing Corp.,"
"
IC1,74HC4067,ADC:74HC_HTC4067,,568-12173-2-ND,NXP Semiconductors,"
"
C1,.1uF,Capacitors_SMD:C_0402,,,,
C3,.1uF,Capacitors_SMD:C_0402,,,,
U2,MCP6001,ADC:MCP6001,,MCP6001T-I/OTCT-ND,Microchip Technology,"
"
R1,10k,Resistors_SMD:R_0402,,,,
U3,MCP6004,ADC:MCP6004,,MCP6004T-I/STCT-ND,Microchip Technology,"
"
R2,1 M ,Resistors_SMD:R_0402,,,,
R4,R,Resistors_SMD:R_0402,,,,
R3,R,Resistors_SMD:R_0402,,,,
R5,10k,Resistors_SMD:R_0402,,,,
C5,.1uF,Capacitors_SMD:C_0402,,,,
R10,1 M ,Resistors_SMD:R_0402,,,,
R11,R,Resistors_SMD:R_0402,,,,
R12,R,Resistors_SMD:R_0402,,,,
R13,10k,Resistors_SMD:R_0402,,,,
R14,1 M ,Resistors_SMD:R_0402,,,,
R15,R,Resistors_SMD:R_0402,,,,
R16,R,Resistors_SMD:R_0402,,,,
R17,10k,Resistors_SMD:R_0402,,,,
R6,1 M ,Resistors_SMD:R_0402,,,,
R7,R,Resistors_SMD:R_0402,,,,
R8,R,Resistors_SMD:R_0402,,,,
R9,10k,Resistors_SMD:R_0402,,,,
C6,.1uF,Capacitors_SMD:C_0402,,,,
C8,.1uF,Capacitors_SMD:C_0402,,,,
C7,.1uF,Capacitors_SMD:C_0402,,,,
C9,.1uF,Capacitors_SMD:C_0402,,,,
U4,MCP6004,ADC:MCP6004,,MCP6004T-I/STCT-ND,Microchip Technology,"
"
R18,1 M ,Resistors_SMD:R_0402,,,,
R20,R,Resistors_SMD:R_0402,,,,
R19,R,Resistors_SMD:R_0402,,,,
R21,10k,Resistors_SMD:R_0402,,,,
C10,.1uF,Capacitors_SMD:C_0402,,,,
R26,1 M ,Resistors_SMD:R_0402,,,,
R27,R,Resistors_SMD:R_0402,,,,
R28,R,Resistors_SMD:R_0402,,,,
R29,10k,Resistors_SMD:R_0402,,,,
R30,1 M ,Resistors_SMD:R_0402,,,,
R31,R,Resistors_SMD:R_0402,,,,
R32,R,Resistors_SMD:R_0402,,,,
R33,10k,Resistors_SMD:R_0402,,,,
R22,1 M ,Resistors_SMD:R_0402,,,,
R23,R,Resistors_SMD:R_0402,,,,
R24,R,Resistors_SMD:R_0402,,,,
R25,10k,Resistors_SMD:R_0402,,,,
C11,.1uF,Capacitors_SMD:C_0402,,,,
C13,.1uF,Capacitors_SMD:C_0402,,,,
C12,.1uF,Capacitors_SMD:C_0402,,,,
C14,.1uF,Capacitors_SMD:C_0402,,,,
U5,MCP6004,ADC:MCP6004,,MCP6004T-I/STCT-ND,Microchip Technology,"
"
R34,1 M ,Resistors_SMD:R_0402,,,,
R36,R,Resistors_SMD:R_0402,,,,
R35,R,Resistors_SMD:R_0402,,,,
R37,10k,Resistors_SMD:R_0402,,,,
C15,.1uF,Capacitors_SMD:C_0402,,,,
R42,1 M ,Resistors_SMD:R_0402,,,,
R43,R,Resistors_SMD:R_0402,,,,
R44,R,Resistors_SMD:R_0402,,,,
R45,10k,Resistors_SMD:R_0402,,,,
R46,1 M ,Resistors_SMD:R_0402,,,,
R47,R,Resistors_SMD:R_0402,,,,
R48,R,Resistors_SMD:R_0402,,,,
R49,10k,Resistors_SMD:R_0402,,,,
R38,1 M ,Resistors_SMD:R_0402,,,,
R39,R,Resistors_SMD:R_0402,,,,
R40,R,Resistors_SMD:R_0402,,,,
R41,10k,Resistors_SMD:R_0402,,,,
C16,.1uF,Capacitors_SMD:C_0402,,,,
C18,.1uF,Capacitors_SMD:C_0402,,,,
C17,.1uF,Capacitors_SMD:C_0402,,,,
C19,.1uF,Capacitors_SMD:C_0402,,,,
U6,MCP6004,ADC:MCP6004,,MCP6004T-I/STCT-ND,Microchip Technology,"
"
R50,1 M ,Resistors_SMD:R_0402,,,,
R52,R,Resistors_SMD:R_0402,,,,
R51,R,Resistors_SMD:R_0402,,,,
R53,10k,Resistors_SMD:R_0402,,,,
C20,.1uF,Capacitors_SMD:C_0402,,,,
R58,1 M ,Resistors_SMD:R_0402,,,,
R59,R,Resistors_SMD:R_0402,,,,
R60,R,Resistors_SMD:R_0402,,,,
R61,10k,Resistors_SMD:R_0402,,,,
R62,1 M ,Resistors_SMD:R_0402,,,,
R63,R,Resistors_SMD:R_0402,,,,
R64,R,Resistors_SMD:R_0402,,,,
R65,10k,Resistors_SMD:R_0402,,,,
R54,1 M ,Resistors_SMD:R_0402,,,,
R55,R,Resistors_SMD:R_0402,,,,
R56,R,Resistors_SMD:R_0402,,,,
R57,10k,Resistors_SMD:R_0402,,,,
C21,.1uF,Capacitors_SMD:C_0402,,,,
C23,.1uF,Capacitors_SMD:C_0402,,,,
C22,.1uF,Capacitors_SMD:C_0402,,,,
C24,.1uF,Capacitors_SMD:C_0402,,,,

## KiCad design PWM/pwm.kicad_pcb

Board: 4 copper layers, 33.0 x 66.0 mm, 66 parts (0 on the bottom side), 43 nets.

Parts:
C1, C2, C5, C6, C7, C8, C9: 0.1uF; C_0402
C3, C4: 1uF; C_0402
C10: 0.1uF; R_0402
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16: ZHCS506TA
P1: CONN_01X25_1; 25_pin_10in
P2: CONN_01X25_2; 25_pin_10in
P3, P4: CONN_01X10; 10pin_tenth_in
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12, Q13, Q14, Q15, Q16: AO3422
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R18: 10K; R_0402
R17: 2.2k; R_0402
U1: TLV1117LV33DCYR
U2: TLC5940PWP

Connections:
+3V3: C1.1, C2.1, C4.1, C9.1, C10.1, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R18.1, U1.2, U1.Tab, U2.26, U2.28
+5V: C3.1, P2.23, P2.24, U1.3
+24V: C5.1, C6.1, C7.1, C8.1, D1.1, D2.1, D3.1, D4.1, D5.1, D6.1, D7.1, D8.1, D9.1, D10.1, D11.1, D12.1, D13.1, D14.1, D15.1, D16.1, P1.3, P1.5, P1.7, P1.9, P1.12, P1.14, P1.16, P1.18, P2.3, P2.5, P2.7, P2.9, P2.12, P2.14, P2.16, P2.18, P3.1, P3.2, P3.3, P3.4, P3.5, P3.6, P3.7, P3.8, P3.9, P3.10
/BLANK: P2.21, U2.2
/GATE0: Q1.1, R1.2, U2.7
/GATE1: Q2.1, R2.2, U2.8
/GATE2: Q3.1, R3.2, U2.9
/GATE3: Q4.1, R4.2, U2.10
/GATE4: Q5.1, R5.2, U2.11
/GATE5: Q6.1, R6.2, U2.12
/GATE6: Q7.1, R7.2, U2.13
/GATE7: Q8.1, R8.2, U2.14
/GATE8: Q9.1, R9.2, U2.15
/GATE9: Q10.1, R10.2, U2.16
/GATE10: Q11.1, R11.2, U2.17
/GATE11: Q12.1, R12.2, U2.18
/GATE12: Q13.1, R13.2, U2.19
/GATE13: Q14.1, R14.2, U2.20
/GATE14: Q15.1, R15.2, U2.21
/GATE15: Q16.1, R16.2, U2.22
/GSCLK: P1.20, R18.2, U2.25
/OUT_0: D1.3, P1.2, Q1.3
/OUT_1: D2.3, P2.2, Q2.3
/OUT_2: D3.3, P1.4, Q3.3
/OUT_3: D4.3, P2.4, Q4.3
/OUT_4: D5.3, P1.6, Q5.3
/OUT_5: D6.3, P2.6, Q6.3
/OUT_6: D7.3, P1.8, Q7.3
/OUT_7: D8.3, P2.8, Q8.3
/OUT_8: D9.3, P1.11, Q9.3
/OUT_9: D10.3, P2.11, Q10.3
/OUT_10: D11.3, P1.13, Q11.3
/OUT_11: D12.3, P2.13, Q12.3
/OUT_12: D13.3, P1.15, Q13.3
/OUT_13: D14.3, P2.15, Q14.3
/OUT_14: D15.3, P1.17, Q15.3
/OUT_15: D16.3, P2.17, Q16.3
/SCLK: P1.22, U2.4
/SIN: P1.23, U2.5
/SOUT: P1.24, U2.24
/XLAT: P1.21, U2.3
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, P1.1, P1.10, P1.19, P1.25, P2.1, P2.10, P2.19, P2.25, P4.1, P4.2, P4.3, P4.4, P4.5, P4.6, P4.7, P4.8, P4.9, P4.10, Q1.2, Q2.2, Q3.2, Q4.2, Q5.2, Q6.2, Q7.2, Q8.2, Q9.2, Q10.2, Q11.2, Q12.2, Q13.2, Q14.2, Q15.2, Q16.2, R17.2, U1.1, U2.1, U2.6
unnamed: R17.1, U2.27

## KiCad design Motherboard/Motherboard.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14: 1uF; FK18X5R0J105K
C15, C16, C17, C18: 10 uF; FK18X5R0J105K
J2: DB9-M; DB9FC
J4: CONN_02X03; 2x3_pin_10in
M1, M2, M3, M4, M5, M6, M7: CONN_02X25; 50_pin_10in
M8: CONN_02X09; 2x_9_pin_10in
P1, P2, P3, P4, P5, P6, P7, P8, P9, P10, P11, P12, P13, P14, P15, P16: CONN_02X07; 2x7_pin_10in
P17, P18, P19, P20, P21, P22, P23, P24, P25, P26, P27, P28, P29, P30: 9_R_01X10; 10_pin_10in
U1, U2, U3, U4: CONN_02X12; 24_pin_10in

Connections:
+5V: M1.46, M1.48, M2.46, M2.48, M3.46, M3.48, M4.46, M4.48, M5.46, M5.48, M6.46, M6.48, M7.46, M7.48, M8.15, U1.2, U2.2, U3.2, U4.2; also elsewhere on the board
/A: J2.2, J2.11, M8.16
/B: J2.3, J2.12, M8.18
/FAN+01: M1.5, P1.13
/FAN+02: M1.6, P2.13
/FAN+03: M1.9, P3.13
/FAN+04: M1.10, P4.13
/FAN+05: M1.13, P5.13
/FAN+06: M1.14, P6.13
/FAN+07: M1.17, P7.13
/FAN+08: M1.18, P8.13
/FAN+09: M1.23, P9.13
/FAN+10: M1.24, P10.13
/FAN+11: M1.27, P11.13
/FAN+12: M1.28, P12.13
/FAN+13: M1.31, P13.13
/FAN+14: M1.32, P14.13
/FAN+15: M1.35, P15.13
/FAN+16: M1.36, P16.13
/FAN-01: M1.3, P1.14, P17.9
/FAN-02: M1.4, P2.14, P18.9
/FAN-03: M1.7, P3.14, P17.8
/FAN-04: M1.8, P4.14, P18.8
/FAN-05: M1.11, P5.14, P17.7
/FAN-06: M1.12, P6.14, P18.7
/FAN-07: M1.15, P7.14, P17.6
/FAN-08: M1.16, P8.14, P18.6
/FAN-09: M1.21, P9.14, P17.5
/FAN-10: M1.22, P10.14, P18.5
/FAN-11: M1.25, P11.14, P17.4
/FAN-12: M1.26, P12.14, P18.4
/FAN-13: M1.29, P13.14, P17.3
/FAN-14: M1.30, P14.14, P18.3
/FAN-15: M1.33, P15.14, P17.2
/FAN-16: M1.34, P16.14, P18.2
/HTR+01: M2.5, P1.11
/HTR+02: M2.6, P2.11
/HTR+03: M2.9, P3.11
/HTR+04: M2.10, P4.11
/HTR+05: M2.13, P5.11
/HTR+06: M2.14, P6.11
/HTR+07: M2.17, P7.11
/HTR+08: M2.18, P8.11
/HTR+09: M2.23, P9.11
/HTR+10: M2.24, P10.11
/HTR+11: M2.27, P11.11
/HTR+12: M2.28, P12.11
/HTR+13: M2.31, P13.11
/HTR+14: M2.32, P14.11
/HTR+15: M2.35, P15.11
/HTR+16: M2.36, P16.11
/HTR-01: M2.3, P1.12, P19.9
/HTR-02: M2.4, P2.12, P20.9
/HTR-03: M2.7, P3.12, P19.8
/HTR-04: M2.8, P4.12, P20.8
/HTR-05: M2.11, P5.12, P19.7
/HTR-06: M2.12, P6.12, P20.7
/HTR-07: M2.15, P7.12, P19.6
/HTR-08: M2.16, P8.12, P20.6
/HTR-09: M2.21, P9.12, P19.5
/HTR-10: M2.22, P10.12, P20.5
/HTR-11: M2.25, P11.12, P19.4
/HTR-12: M2.26, P12.12, P20.4
/HTR-13: M2.29, P13.12, P19.3
/HTR-14: M2.30, P14.12, P20.3
/HTR-15: M2.33, P15.12, P19.2
/HTR-16: M2.34, P16.12, P20.2
/LED+01: M4.5, P1.7
/LED+02: M4.6, P2.7
/LED+03: M4.9, P3.7
/LED+04: M4.10, P4.7
/LED+05: M4.13, P5.7
/LED+06: M4.14, P6.7
/LED+07: M4.17, P7.7
/LED+08: M4.18, P8.7
/LED+09: M4.23, P9.7
/LED+10: M4.24, P10.7
/LED+11: M4.27, P11.7
/LED+12: M4.28, P12.7
/LED+13: M4.31, P13.7
/LED+14: M4.32, P14.7
/LED+15: M4.35, P15.7
/LED+16: M4.36, P16.7
/LED-01: M4.3, P1.8, P23.9
/LED-02: M4.4, P2.8, P24.9
/LED-03: M4.7, P3.8, P23.8
/LED-04: M4.8, P4.8, P24.8
/LED-05: M4.11, P5.8, P23.7
/LED-06: M4.12, P6.8, P24.7
/LED-07: M4.15, P7.8, P23.6
/LED-08: M4.16, P8.8, P24.6
/LED-09: M4.21, P9.8, P23.5
/LED-10: M4.22, P10.8, P24.5
/LED-11: M4.25, P11.8, P23.4
/LED-12: M4.26, P12.8, P24.4
/LED-13: M4.29, P13.8, P23.3
/LED-14: M4.30, P14.8, P24.3
/LED-15: M4.33, P15.8, P23.2
/LED-16: M4.34, P16.8, P24.2
/M1_3V3: C1.2, C2.2, M1.40, P17.1, P18.1
/M2_3V3: C3.2, C4.2, M2.40, P19.1, P20.1
/M3_3V3: C5.2, C6.2, M3.40, P21.1, P22.1
/M4_3V3: C7.2, C8.2, M4.40, P23.1, P24.1
/M5_3V3: C9.2, C10.2, M5.40, P25.1, P26.1
/M6_3V3: C11.2, C12.2, M6.40, P27.1, P28.1
/M7_3V3: C13.2, C14.2, M7.40, P29.1, P30.1
/PD+01: M5.5, P1.5
/PD+02: M5.6, P2.5
/PD+03: M5.9, P3.5
/PD+04: M5.10, P4.5
/PD+05: M5.13, P5.5
/PD+06: M5.14, P6.5
/PD+07: M5.17, P7.5
/PD+08: M5.18, P8.5
/PD+09: M5.23, P9.5
/PD+10: M5.24, P10.5
/PD+11: M5.27, P11.5
/PD+12: M5.28, P12.5
/PD+13: M5.31, P13.5
/PD+14: M5.32, P14.5
/PD+15: M5.35, P15.5
/PD+16: M5.36, P16.5
/PD-01: M5.3, P1.6, P25.9
/PD-02: M5.4, P2.6, P26.9
/PD-03: M5.7, P3.6, P25.8
/PD-04: M5.8, P4.6, P26.8
/PD-05: M5.11, P5.6, P25.7
/PD-06: M5.12, P6.6, P26.7
/PD-07: M5.15, P7.6, P25.6
/PD-08: M5.16, P8.6, P26.6
/PD-09: M5.21, P9.6, P25.5
/PD-10: M5.22, P10.6, P26.5
/PD-11: M5.25, P11.6, P25.4
/PD-12: M5.26, P12.6, P26.4
/PD-13: M5.29, P13.6, P25.3
/PD-14: M5.30, P14.6, P26.3
/PD-15: M5.33, P15.6, P25.2
/PD-16: M5.34, P16.6, P26.2
/SPA+01: M7.5, P1.1
/SPA+02: M7.6, P2.1
/SPA+03: M7.9, P3.1
/SPA+04: M7.10, P4.1
/SPA+05: M7.13, P5.1
/SPA+06: M7.14, P6.1
/SPA+07: M7.17, P7.1
/SPA+08: M7.18, P8.1
/SPA+09: M7.23, P9.1
/SPA+10: M7.24, P10.1
/SPA+11: M7.27, P11.1
/SPA+12: M7.28, P12.1
/SPA+13: M7.31, P13.1
/SPA+14: M7.32, P14.1
/SPA+15: M7.35, P15.1
/SPA+16: M7.36, P16.1
/SPA-01: M7.3, P1.2, P29.9
/SPA-02: M7.4, P2.2, P30.9
/SPA-03: M7.7, P3.2, P29.8
/SPA-04: M7.8, P4.2, P30.8
/SPA-05: M7.11, P5.2, P29.7
/SPA-06: M7.12, P6.2, P30.7
/SPA-07: M7.15, P7.2, P29.6
/SPA-08: M7.16, P8.2, P30.6
/SPA-09: M7.21, P9.2, P29.5
/SPA-10: M7.22, P10.2, P30.5
/SPA-11: M7.25, P11.2, P29.4
/SPA-12: M7.26, P12.2, P30.4
/SPA-13: M7.29, P13.2, P29.3
/SPA-14: M7.30, P14.2, P30.3
/SPA-15: M7.33, P15.2, P29.2
/SPA-16: M7.34, P16.2, P30.2
/SPB+01: M6.5, P1.3
/SPB+02: M6.6, P2.3
/SPB+03: M6.9, P3.3
/SPB+04: M6.10, P4.3
/SPB+05: M6.13, P5.3
/SPB+06: M6.14, P6.3
/SPB+07: M6.17, P7.3
/SPB+08: M6.18, P8.3
/SPB+09: M6.23, P9.3
/SPB+10: M6.24, P10.3
/SPB+11: M6.27, P11.3
/SPB+12: M6.28, P12.3
/SPB+13: M6.31, P13.3
/SPB+14: M6.32, P14.3
/SPB+15: M6.35, P15.3
/SPB+16: M6.36, P16.3
/SPB-01: M6.3, P1.4, P27.9
/SPB-02: M6.4, P2.4, P28.9
/SPB-03: M6.7, P3.4, P27.8
/SPB-04: M6.8, P4.4, P28.8
/SPB-05: M6.11, P5.4, P27.7
/SPB-06: M6.12, P6.4, P28.7
/SPB-07: M6.15, P7.4, P27.6
/SPB-08: M6.16, P8.4, P28.6
/SPB-09: M6.21, P9.4, P27.5
/SPB-10: M6.22, P10.4, P28.5
/SPB-11: M6.25, P11.4, P27.4
/SPB-12: M6.26, P12.4, P28.4
/SPB-13: M6.29, P13.4, P27.3
/SPB-14: M6.30, P14.4, P28.3
/SPB-15: M6.33, P15.4, P27.2
/SPB-16: M6.34, P16.4, P28.2
/TS+01: M3.5, P1.9
/TS+02: M3.6, P2.9
/TS+03: M3.9, P3.9
/TS+04: M3.10, P4.9
/TS+05: M3.13, P5.9
/TS+06: M3.14, P6.9
/TS+07: M3.17, P7.9
/TS+08: M3.18, P8.9
/TS+09: M3.23, P9.9
/TS+10: M3.24, P10.9
/TS+11: M3.27, P11.9
/TS+12: M3.28, P12.9
/TS+13: M3.31, P13.9
/TS+14: M3.32, P14.9
/TS+15: M3.35, P15.9
/TS+16: M3.36, P16.9
/TS-01: M3.3, P1.10, P21.9
/TS-02: M3.4, P2.10, P22.9
/TS-03: M3.7, P3.10, P21.8
/TS-04: M3.8, P4.10, P22.8
/TS-05: M3.11, P5.10, P21.7
/TS-06: M3.12, P6.10, P22.7
/TS-07: M3.15, P7.10, P21.6
/TS-08: M3.16, P8.10, P22.6
/TS-09: M3.21, P9.10, P21.5
/TS-10: M3.22, P10.10, P22.5
/TS-11: M3.25, P11.10, P21.4
/TS-12: M3.26, P12.10, P22.4
/TS-13: M3.29, P13.10, P21.3
/TS-14: M3.30, P14.10, P22.3
/TS-15: M3.33, P15.10, P21.2
/TS-16: M3.34, P16.10, P22.2
/UC0_A0: U1.16
/UC0_A1: M1.42, U1.14
/UC0_A2: J4.3, U1.12, U2.12, U3.12, U4.12
/UC0_A3: J4.1, U1.10, U2.10, U3.10, U4.10
/UC0_D2: M1.39, U1.9
/UC0_D3: M1.41, U1.11
/UC0_D4: M1.43, U1.13
/UC0_D5: M1.45, U1.15
/UC0_D6: M1.47, U1.17
/UC0_D7: U1.19
/UC0_D8: U1.21
/UC0_D9: U1.23
/UC0_D10: U1.24
/UC0_D11: U1.22
/UC0_D12: M8.7, U1.20
/UC0_D13: J4.5, U1.18, U2.18, U3.18, U4.18
/UC0_NRST: C15.1, U1.5
/UC0_RX: M8.5, U1.3
/UC0_TX: M8.3, U1.1
/UC1_A0: M3.42, U2.16
/UC1_A1: M2.42, U2.14
/UC1_D2: M2.39, U2.9
/UC1_D3: M2.41, U2.11
/UC1_D4: M2.43, U2.13
/UC1_D5: M2.45, U2.15
/UC1_D6: M2.47, U2.17
/UC1_D7: M3.39, U2.19
/UC1_D8: M3.41, U2.21
/UC1_D9: M3.43, U2.23
/UC1_D10: M3.45, U2.24
/UC1_D11: M3.47, U2.22
/UC1_D12: M8.13, U2.20
/UC1_NRST: C16.1, U2.5
/UC1_RX: M8.11, U2.3
/UC1_TX: M8.9, U2.1
/UC2_A0: M5.42, U3.16
/UC2_A1: M4.42, U3.14
/UC2_D2: M4.39, U3.9
/UC2_D3: M4.41, U3.11
/UC2_D4: M4.43, U3.13
/UC2_D5: M4.45, U3.15
/UC2_D6: M4.47, U3.17
/UC2_D7: M5.39, U3.19
/UC2_D8: M5.41, U3.21
/UC2_D9: M5.43, U3.23
/UC2_D10: M5.45, U3.24
/UC2_D11: M5.47, U3.22
/UC2_D12: M8.8, U3.20
/UC2_NRST: C17.1, U3.5
/UC2_RX: M8.6, U3.3
/UC2_TX: M8.4, U3.1
/UC3_A0: M7.42, U4.16
/UC3_A1: M6.42, U4.14
/UC3_D2: M6.39, U4.9
/UC3_D3: M6.41, U4.11
/UC3_D4: M6.43, U4.13
/UC3_D5: M6.45, U4.15
/UC3_D6: M6.47, U4.17
/UC3_D7: M7.39, U4.19
/UC3_D8: M7.41, U4.21
/UC3_D9: M7.43, U4.23
/UC3_D10: M7.45, U4.24
/UC3_D11: M7.47, U4.22
/UC3_D12: M8.14, U4.20
/UC3_NRST: C18.1, U4.5
/UC3_RX: M8.12, U4.3
/UC3_TX: M8.10, U4.1
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.2, C16.2, C17.2, C18.2, J2.5, J2.14, J4.2, J4.4, J4.6, M1.1, M1.2, M1.19, M1.20, M1.37, M1.38, M1.49, M1.50, M2.1, M2.2, M2.19, M2.20, M2.37, M2.38, M2.49, M2.50, M3.1, M3.2, M3.19, M3.20, M3.37, M3.38, M3.49, M3.50, M4.1, M4.2, M4.19, M4.20, M4.37, M4.38, M4.49, M4.50, M5.1, M5.2, M5.19, M5.20, M5.37, M5.38, M5.49, M5.50, M6.1, M6.2, M6.19, M6.20, M6.37, M6.38, M6.49, M6.50, M7.1, M7.2, M7.19, M7.20, M7.37, M7.38, M7.49, M7.50, M8.1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; also elsewhere on the board

Notes on the sheet:
Fan/Stir
Temperature
Optical Density
Spare
PWM (fan)
PWM (heat)
RS-485
ADC (temp)
PWM (LED)
ADC (PD)
PWM/ADC (spare)
POWER
RS-485 Output
Motherboard id

Parts:
GND_M1, GND_M2, GND_M3, GND_M4, GND_M5, GND_M6, GND_M7: CONN_01X10; 10_pin_10in
P31: CONN_01X16; 1723162216
PWR_M1, PWR_M2, PWR_M3, PWR_M4, PWR_M5, PWR_M6, PWR_M7: CONN_01X10; 10_pin_10in

Connections:
+5V: P31.15; also elsewhere on the board
GND: GND_M1.1, GND_M1.2, GND_M1.3, GND_M1.4, GND_M1.5, GND_M1.6, GND_M1.7, GND_M1.8, GND_M1.9, GND_M1.10, GND_M2.1, GND_M2.2, GND_M2.3, GND_M2.4, GND_M2.5, GND_M2.6, GND_M2.7, GND_M2.8, GND_M2.9, GND_M2.10, GND_M3.1, GND_M3.2, GND_M3.3, GND_M3.4, GND_M3.5, GND_M3.6, GND_M3.7, GND_M3.8, GND_M3.9, GND_M3.10, GND_M4.1, GND_M4.2, GND_M4.3, GND_M4.4, GND_M4.5, GND_M4.6, GND_M4.7, GND_M4.8, GND_M4.9, GND_M4.10, GND_M5.1, GND_M5.2, GND_M5.3, GND_M5.4, GND_M5.5, GND_M5.6, GND_M5.7, GND_M5.8, GND_M5.9, GND_M5.10, GND_M6.1, GND_M6.2, GND_M6.3, GND_M6.4, GND_M6.5, GND_M6.6, GND_M6.7, GND_M6.8, GND_M6.9, GND_M6.10, GND_M7.1, GND_M7.2, GND_M7.3, GND_M7.4, GND_M7.5, GND_M7.6, GND_M7.7, GND_M7.8, GND_M7.9, GND_M7.10, P31.2, P31.4, P31.6, P31.8, P31.10, P31.12, P31.14, P31.16; also elsewhere on the board
unnamed: P31.1, PWR_M7.1, PWR_M7.2, PWR_M7.3, PWR_M7.4, PWR_M7.5, PWR_M7.6, PWR_M7.7, PWR_M7.8, PWR_M7.9, PWR_M7.10
unnamed: P31.3, PWR_M6.1, PWR_M6.2, PWR_M6.3, PWR_M6.4, PWR_M6.5, PWR_M6.6, PWR_M6.7, PWR_M6.8, PWR_M6.9, PWR_M6.10
unnamed: P31.5, PWR_M5.1, PWR_M5.2, PWR_M5.3, PWR_M5.4, PWR_M5.5, PWR_M5.6, PWR_M5.7, PWR_M5.8, PWR_M5.9, PWR_M5.10
unnamed: P31.7, PWR_M4.1, PWR_M4.2, PWR_M4.3, PWR_M4.4, PWR_M4.5, PWR_M4.6, PWR_M4.7, PWR_M4.8, PWR_M4.9, PWR_M4.10
unnamed: P31.9, PWR_M3.1, PWR_M3.2, PWR_M3.3, PWR_M3.4, PWR_M3.5, PWR_M3.6, PWR_M3.7, PWR_M3.8, PWR_M3.9, PWR_M3.10
unnamed: P31.11, PWR_M2.1, PWR_M2.2, PWR_M2.3, PWR_M2.4, PWR_M2.5, PWR_M2.6, PWR_M2.7, PWR_M2.8, PWR_M2.9, PWR_M2.10
unnamed: P31.13, PWR_M1.1, PWR_M1.2, PWR_M1.3, PWR_M1.4, PWR_M1.5, PWR_M1.6, PWR_M1.7, PWR_M1.8, PWR_M1.9, PWR_M1.10

Notes on the sheet:
Extra power for PWM boards (put on all sites for flexibility)
Power Input (Molex Ultra-Fit)

Board: 4 copper layers, 279.4 x 254.0 mm, 77 parts (0 on the bottom side), 303 nets.
