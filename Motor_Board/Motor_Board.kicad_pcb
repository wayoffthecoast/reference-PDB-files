# Repository wayoffthecoast/reference-PDB-files

## KiCad design Motor_Board/Motor_Board.kicad_pcb

Parts:
C1, C6: 10uF; C_0402_1005Metric_lines
C2, C3, C4, C5, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C25, C26, C27, C28, C29, C30, C31, C32, C37, C38, C39, C40, C41, C42, C43, C44, C49, C50, C51, C52, C53, C54, C55, C56, C77, C78: .1uF; C_0402_1005Metric_lines
C21, C22, C23, C24, C33, C34, C35, C36, C45, C46, C47, C48, C57, C58, C59, C60: .022uF; C_0402_1005Metric_lines
C61, C62, C63, C64, C65, C66, C67, C68, C69, C70, C71, C72, C73, C74, C75, C76: omit; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18: RED; D_0402_1005Metric_lines
J1: serial_conn1; PinSocket_1x25_P2.54mm_Vertical
J2: serial_conn2; PinSocket_1x25_P2.54mm_Vertical
J4: PWR_conn; PinSocket_1x10_P2.54mm_Vertical
J5: GND_conn; PinSocket_1x10_P2.54mm_Vertical
R1, R2: 10k; R_0402_1005Metric_lines
R3, R4, R11, R12, R13, R14, R19, R20, R21, R22, R27, R28, R29, R30, R35, R36, R37, R38: 130; R_0402_1005Metric_lines
R5, R6: 2.2k; R_0402_1005Metric_lines
R7, R8, R10, R15, R16, R17, R18, R23, R24, R25, R26, R31, R32, R33, R34: 3.3k; R_0402_1005Metric_lines
R9: 3.3k; R_0402_1005Metric
R39, R40: Omit; C_0402_1005Metric_lines
U1: TLV1117LV33DCYR; SOT-23-5
U2, U3: TLC5940PWP; HTSSOP-28-1EP_4.4x9.7mm_P0.65mm_EP2.85x5.4mm_ThermalVias
U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14, U15, U16, U17, U18, U19: DRV8876PWP; QFN-16-1EP_3x3mm_P0.5mm_EP1.75x1.75mm_ThermalVias

Connections:
+3V3: C2.1, C3.1, C4.1, C5.1, C6.1, C11.1, C12.1, D1.2 (A), D2.2 (A), J2.20, R1.2, R2.2, R11.2, R12.2, R13.2, R14.2, R19.2, R20.2, R21.2, R22.2, R27.2, R28.2, R29.2, R30.2, R35.2, R36.2, R37.2, R38.2, R39.1, U1.5 (Vout), U2.26 (DCPRG), U2.28 (Vcc), U3.26 (DCPRG), U3.28 (Vcc), U4.1 (nSLEEP), U4.3 (Vref), U5.1 (nSLEEP), U5.3 (Vref), U6.1 (nSLEEP), U6.3 (Vref), U7.1 (nSLEEP), U7.3 (Vref), U8.1 (nSLEEP), U8.3 (Vref), U9.1 (nSLEEP), U9.3 (Vref), U10.1 (nSLEEP), U10.3 (Vref), U11.1 (nSLEEP), U11.3 (Vref), U12.1 (nSLEEP), U12.3 (Vref), U13.1 (nSLEEP), U13.3 (Vref), U14.1 (nSLEEP), U14.3 (Vref), U15.1 (nSLEEP), U15.3 (Vref), U16.1 (nSLEEP), U16.3 (Vref), U17.1 (nSLEEP), U17.3 (Vref), U18.1 (nSLEEP), U18.3 (Vref), U19.1 (nSLEEP), U19.3 (Vref)
+5V: C1.1, J2.23, J2.24, U1.1 (Vin), U1.3 (CE)
+24V: C7.1, C8.1, C9.1, C10.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, C49.1, C50.1, C51.1, C52.1, C53.1, C54.1, C55.1, C56.1, C61.1, C62.1, C63.1, C64.1, C65.1, C66.1, C67.1, C68.1, C69.1, C70.1, C71.1, C72.1, C73.1, C74.1, C75.1, C76.1, J4.1, J4.2, J4.3, J4.4, J4.5, J4.6, J4.7, J4.8, J4.9, J4.10, U4.9 (Vm), U5.9 (Vm), U6.9 (Vm), U7.9 (Vm), U8.9 (Vm), U9.9 (Vm), U10.9 (Vm), U11.9 (Vm), U12.9 (Vm), U13.9 (Vm), U14.9 (Vm), U15.9 (Vm), U16.9 (Vm), U17.9 (Vm), U18.9 (Vm), U19.9 (Vm)
/GSCLK: J1.20, R1.1, R2.1, U2.25 (GSCLK), U3.25 (GSCLK)
/H0a: U2.8 (OUT1), U4.15 (EN)
/H0b: U2.7 (OUT0), U4.16 (PH)
/H1a: U3.22 (OUT15), U8.15 (EN)
/H1b: U3.21 (OUT14), U8.16 (PH)
/H2a: U2.10 (OUT3), U12.15 (EN)
/H2b: U2.9 (OUT2), U12.16 (PH)
/H3a: U3.20 (OUT13), U16.15 (EN)
/H3b: U3.19 (OUT12), U16.16 (PH)
/H4a: U2.12 (OUT5), U5.15 (EN)
/H4b: U2.11 (OUT4), U5.16 (PH)
/H5a: U3.18 (OUT11), U9.15 (EN)
/H5b: U3.17 (OUT10), U9.16 (PH)
/H6a: U2.14 (OUT7), U13.15 (EN)
/H6b: U2.13 (OUT6), U13.16 (PH)
/H7a: U3.16 (OUT9), U17.15 (EN)
/H7b: U3.15 (OUT8), U17.16 (PH)
/H8a: U2.16 (OUT9), U6.15 (EN)
/H8b: U2.15 (OUT8), U6.16 (PH)
/H9a: U3.14 (OUT7), U10.15 (EN)
/H9b: U3.13 (OUT6), U10.16 (PH)
/H10a: U2.18 (OUT11), U14.15 (EN)
/H10b: U2.17 (OUT10), U14.16 (PH)
/H11a: U3.12 (OUT5), U18.15 (EN)
/H11b: U3.11 (OUT4), U18.16 (PH)
/H12a: U2.20 (OUT13), U7.15 (EN)
/H12b: U2.19 (OUT12), U7.16 (PH)
/H13a: U3.10 (OUT3), U11.15 (EN)
/H13b: U3.9 (OUT2), U11.16 (PH)
/H14a: U2.22 (OUT15), U15.15 (EN)
/H14b: U2.21 (OUT14), U15.16 (PH)
/H15a: U3.8 (OUT1), U19.15 (EN)
/H15b: U3.7 (OUT0), U19.16 (PH)
/OUT_0a: J1.2, U4.6 (OUT1)
/OUT_0b: J1.3, U4.8 (OUT2)
/OUT_1a: J2.2, U8.6 (OUT1)
/OUT_1b: J2.3, U8.8 (OUT2)
/OUT_2a: J1.4, U12.6 (OUT1)
/OUT_2b: J1.5, U12.8 (OUT2)
/OUT_3a: J2.4, U16.6 (OUT1)
/OUT_3b: J2.5, U16.8 (OUT2)
/OUT_4a: J1.6, U5.6 (OUT1)
/OUT_4b: J1.7, U5.8 (OUT2)
/OUT_5a: J2.6, U9.6 (OUT1)
/OUT_5b: J2.7, U9.8 (OUT2)
/OUT_6a: J1.8, U13.6 (OUT1)
/OUT_6b: J1.9, U13.8 (OUT2)
/OUT_7a: J2.8, U17.6 (OUT1)
/OUT_7b: J2.9, U17.8 (OUT2)
/OUT_8a: J1.11, U6.6 (OUT1)
/OUT_8b: J1.12, U6.8 (OUT2)
/OUT_9a: J2.11, U10.6 (OUT1)
/OUT_9b: J2.12, U10.8 (OUT2)
/OUT_10a: J1.13, U14.6 (OUT1)
/OUT_10b: J1.14, U14.8 (OUT2)
/OUT_11a: J2.13, U18.6 (OUT1)
/OUT_11b: J2.14, U18.8 (OUT2)
/OUT_12a: J1.15, U7.6 (OUT1)
/OUT_12b: J1.16, U7.8 (OUT2)
/OUT_13a: J2.15, U11.6 (OUT1)
/OUT_13b: J2.16, U11.8 (OUT2)
/OUT_14a: J1.17, U15.6 (OUT1)
/OUT_14b: J1.18, U15.8 (OUT2)
/OUT_15a: J2.17, U19.6 (OUT1)
/OUT_15b: J2.18, U19.8 (OUT2)
/PMODE: C77.1, C78.1, R39.2, R40.1, U4.14 (PMODE), U5.14 (PMODE), U6.14 (PMODE), U7.14 (PMODE), U8.14 (PMODE), U9.14 (PMODE), U10.14 (PMODE), U11.14 (PMODE), U12.14 (PMODE), U13.14 (PMODE), U14.14 (PMODE), U15.14 (PMODE), U16.14 (PMODE), U17.14 (PMODE), U18.14 (PMODE), U19.14 (PMODE)
/SCLK: J1.22, U2.4 (SCLK), U3.4 (SCLK)
/SIN: J1.23, U2.5 (SIN)
/SMID: U2.24 (SOUT), U3.5 (SIN)
/SOUT: J1.24, U3.24 (SOUT)
/Vadc0: R7.2, U4.4 (IPROPI)
/Vadc1: R15.2, U8.4 (IPROPI)
/Vadc2: R23.2, U12.4 (IPROPI)
/Vadc3: R31.2, U16.4 (IPROPI)
/Vadc4: R8.2, U5.4 (IPROPI)
/Vadc5: R16.2, U9.4 (IPROPI)
/Vadc6: R24.2, U13.4 (IPROPI)
/Vadc7: R32.2, U17.4 (IPROPI)
/Vadc8: R9.2, U6.4 (IPROPI)
/Vadc9: R17.2, U10.4 (IPROPI)
/Vadc10: R25.2, U14.4 (IPROPI)
/Vadc11: R33.2, U18.4 (IPROPI)
/Vadc12: R10.2, U7.4 (IPROPI)
/Vadc13: R18.2, U11.4 (IPROPI)
/Vadc14: R26.2, U15.4 (IPROPI)
/Vadc15: R34.2, U19.4 (IPROPI)
/XLAT: J1.21, U2.3 (XLAT), U3.3 (XLAT)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C25.2, C26.2, C27.2, C28.2, C37.2, C38.2, C39.2, C40.2, C49.2, C50.2, C51.2, C52.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, C72.2, C73.2, C74.2, C75.2, C76.2, C77.2, C78.2, J1.1, J1.10, J1.19, J1.25, J2.1, J2.10, J2.19, J2.25, J5.1, J5.2, J5.3, J5.4, J5.5, J5.6, J5.7, J5.8, J5.9, J5.10, R5.2, R6.2, R7.1, R8.1, R9.1, R10.1, R15.1, R16.1, R17.1, R18.1, R23.1, R24.1, R25.1, R26.1, R31.1, R32.1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
unnamed: C17.2, U4.10 (Vcp)
unnamed: C18.2, U5.10 (Vcp)
unnamed: C19.2, U6.10 (Vcp)
unnamed: C20.2, U7.10 (Vcp)
unnamed: C21.1, U4.11 (CPH)
unnamed: C21.2, U4.12 (CPL)
unnamed: C22.1, U5.11 (CPH)
unnamed: C22.2, U5.12 (CPL)
unnamed: C23.1, U6.11 (CPH)
unnamed: C23.2, U6.12 (CPL)
unnamed: C24.1, U7.11 (CPH)
unnamed: C24.2, U7.12 (CPL)
unnamed: C29.2, U8.10 (Vcp)
unnamed: C30.2, U9.10 (Vcp)
unnamed: C31.2, U10.10 (Vcp)
unnamed: C32.2, U11.10 (Vcp)
unnamed: C33.1, U8.11 (CPH)
unnamed: C33.2, U8.12 (CPL)
unnamed: C34.1, U9.11 (CPH)
unnamed: C34.2, U9.12 (CPL)
unnamed: C35.1, U10.11 (CPH)
unnamed: C35.2, U10.12 (CPL)
unnamed: C36.1, U11.11 (CPH)
unnamed: C36.2, U11.12 (CPL)
unnamed: C41.2, U12.10 (Vcp)
unnamed: C42.2, U13.10 (Vcp)
unnamed: C43.2, U14.10 (Vcp)
unnamed: C44.2, U15.10 (Vcp)
unnamed: C45.1, U12.11 (CPH)
unnamed: C45.2, U12.12 (CPL)
unnamed: C46.1, U13.11 (CPH)
unnamed: C46.2, U13.12 (CPL)
unnamed: C47.1, U14.11 (CPH)
unnamed: C47.2, U14.12 (CPL)
unnamed: C48.1, U15.11 (CPH)
unnamed: C48.2, U15.12 (CPL)
unnamed: C53.2, U16.10 (Vcp)
unnamed: C54.2, U17.10 (Vcp)
unnamed: C55.2, U18.10 (Vcp)
unnamed: C56.2, U19.10 (Vcp)
unnamed: C57.1, U16.11 (CPH)
unnamed: C57.2, U16.12 (CPL)
unnamed: C58.1, U17.11 (CPH)
unnamed: C58.2, U17.12 (CPL)
unnamed: C59.1, U18.11 (CPH)
unnamed: C59.2, U18.12 (CPL)
unnamed: C60.1, U19.11 (CPH)
unnamed: C60.2, U19.12 (CPL)
unnamed: D1.1 (K), R3.1
unnamed: D2.1 (K), R4.1
unnamed: D3.1 (K), U4.2 (nFAULT)
unnamed: D3.2 (A), R11.1
unnamed: D4.1 (K), U5.2 (nFAULT)
unnamed: D4.2 (A), R12.1
unnamed: D5.1 (K), U6.2 (nFAULT)
unnamed: D5.2 (A), R13.1
unnamed: D6.1 (K), U7.2 (nFAULT)
unnamed: D6.2 (A), R14.1
unnamed: D7.1 (K), U8.2 (nFAULT)
unnamed: D7.2 (A), R19.1
unnamed: D8.1 (K), U9.2 (nFAULT)
unnamed: D8.2 (A), R20.1
unnamed: D9.1 (K), U10.2 (nFAULT)
unnamed: D9.2 (A), R21.1
unnamed: D10.1 (K), U11.2 (nFAULT)
unnamed: D10.2 (A), R22.1
unnamed: D11.1 (K), U12.2 (nFAULT)
unnamed: D11.2 (A), R27.1
unnamed: D12.1 (K), U13.2 (nFAULT)
unnamed: D12.2 (A), R28.1
unnamed: D13.1 (K), U14.2 (nFAULT)
unnamed: D13.2 (A), R29.1
unnamed: D14.1 (K), U15.2 (nFAULT)
unnamed: D14.2 (A), R30.1
unnamed: D15.1 (K), U16.2 (nFAULT)
unnamed: D15.2 (A), R35.1
unnamed: D16.1 (K), U17.2 (nFAULT)
unnamed: D16.2 (A), R36.1
unnamed: D17.1 (K), U18.2 (nFAULT)
unnamed: D17.2 (A), R37.1
unnamed: D18.1 (K), U19.2 (nFAULT)
unnamed: D18.2 (A), R38.1
unnamed: R3.2, U2.23 (XERR)
unnamed: R4.2, U3.23 (XERR)
unnamed: R5.1, U2.27 (Iref)
unnamed: R6.1, U3.27 (Iref)

Notes on the sheet:
Connectors
Controllers
H-Bridges
3.3V here is questionable?
GND
Power
Distribute across PCB
X5R ceramic caps
nFAULT goes low on error
is there going to be enough power for this all?
Ripropi
Vadc = 3.3V, value from Vcc of ADC board
Ripropi = Vadc / (Imax * (1000uA/A))
Say Imax = 1A
Ripropi = 3.3kOhm
Vref = Vadc
nSLEEP pulled high
10mA if nFAULT = 0V
25 Watts/H-Bridge, 400? Watts total
For KiCad to understand power
Goes to big connector, maybe test point instead?
Vout = Vm + .9V = 25V
Iout = Imax = 1A given Vref = 3.3V and Ripropi = 3.3k
Pout = 25W theoretical max?
httssop 28
figure out therm pad
even, left side of board
odd, right side of board
Default to GND

Board: 4 copper layers, 33.0 x 66.0 mm, 159 parts (4 on the bottom side), 177 nets.

File Motor_Board/Motor_Board_BOM.csv (part):

"Source:","/home/kremerme/work/svn/evolver-system/Hardware/Motor_Board/trunk/Motor_Board.sch"
"Date:","Thu 06 Aug 2020 09:51:36 AM EDT"
"Tool:","Eeschema 5.1.5+dfsg1-2build2"
"Generator:","/usr/share/kicad/plugins/bom_csv_grouped_by_value.py"
"Component Count:","159"

"Individual Components:"

"Item","Qty","Reference(s)","Value","LibPart","Footprint","Datasheet","Item Cost","MFN","Supplier","Supplier P/N"
"","","C1","10uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://media.digikey.com/pdf/Data%20Sheets/Samsung%20PDFs/C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","0.22","CL05A106MP5NUNC","Digi-key","1276-1450-1-ND"
"","","C2",".1uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://search.murata.co.jp/Ceramy/image/img/A01X/G101/ENG/G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","0.10","GRM155R71H104KE14J","Digi-key","490-13342-1-ND"
"","","C3",".1uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://search.murata.co.jp/Ceramy/image/img/A01X/G101/ENG/G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","0.10","GRM155R71H104KE14J","Digi-key","490-13342-1-ND"
"","","C4",".1uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://search.murata.co.jp/Ceramy/image/img/A01X/G101/ENG/G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","0.10","GRM155R71H104KE14J","Digi-key","490-13342-1-ND"
"","","C5",".1uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://search.murata.co.jp/Ceramy/image/img/A01X/G101/ENG/G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","0.10","GRM155R71H104KE14J","Digi-key","490-13342-1-ND"
"","","C6","10uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://media.digikey.com/pdf/Data%20Sheets/Samsung%20PDFs/C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","0.22","CL05A106MP5NUNC","Digi-key","1276-1450-1-ND"
"","","C7",".1uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://search.murata.co.jp/Ceramy/image/img/A01X/G101/ENG/G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","0.10","GRM155R71H104KE14J","Digi-key","490-13342-1-ND"
"","","C8",".1uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://search.murata.co.jp/Ceramy/image/img/A01X/G101/ENG/G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","0.10","GRM155R71H104KE14J","Digi-key","490-13342-1-ND"
"","","C9",".1uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://search.murata.co.jp/Ceramy/image/img/A01X/G101/ENG/G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","0.10","GRM155R71H104KE14J","Digi-key","490-13342-1-ND"
"","","C10",".1uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://search.murata.co.jp/Ceramy/image/img/A01X/G101/ENG/G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","0.10","GRM155R71H104KE14J","Digi-key","490-13342-1-ND"
"","","C11",".1uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://search.murata.co.jp/Ceramy/image/img/A01X/G101/ENG/G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","0.10","GRM155R71H104KE14J","Digi-key","490-13342-1-ND"
"","","C12",".1uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://search.murata.co.jp/Ceramy/image/img/A01X/G101/ENG/G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","0.10","GRM155R71H104KE14J","Digi-key","490-13342-1-ND"
"","","C13",".1uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://product.tdk.com/info/en/catalog/datasheets/mlcc_comm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","0.11","GRM155R71H104KE14J","Digi-key","445-5932-1-ND"
"","","C14",".1uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://product.tdk.com/info/en/catalog/datasheets/mlcc_comm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","0.11","GRM155R71H104KE14J","Digi-key","445-5932-1-ND"
"","","C15",".1uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://product.tdk.com/info/en/catalog/datasheets/mlcc_comm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","0.11","GRM155R71H104KE14J","Digi-key","445-5932-1-ND"
"","","C16",".1uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://product.tdk.com/info/en/catalog/datasheets/mlcc_comm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","0.10","GRM155R71H104KE14J","Digi-key","490-13342-1-ND"
"","","C17",".1uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://product.tdk.com/info/en/catalog/datasheets/mlcc_comm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","0.11","GRM155R71H104KE14J","Digi-key","445-5932-1-ND"
"","","C18",".1uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://product.tdk.com/info/en/catalog/datasheets/mlcc_comm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","0.11","GRM155R71H104KE14J","Digi-key","445-5932-1-ND"
"","","C19",".1uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://product.tdk.com/info/en/catalog/datasheets/mlcc_comm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","0.11","GRM155R71H104KE14J","Digi-key","445-5932-1-ND"
"","","C20",".1uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://product.tdk.com/info/en/catalog/datasheets/mlcc_comm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","0.10","GRM155R71H104KE14J","Digi-key","490-13342-1-ND"
"","","C21",".022uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://product.tdk.com/info/en/catalog/datasheets/mlcc_comm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","0.10","C1005X7R1E223M050BB","Digi-key","445-4938-1-ND"
"","","C22",".022uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://product.tdk.com/info/en/catalog/datasheets/mlcc_comm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","0.10","C1005X7R1E223M050BB","Digi-key","445-4938-1-ND"
"","","C23",".022uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://product.tdk.com/info/en/catalog/datasheets/mlcc_comm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","0.10","C1005X7R1E223M050BB","Digi-key","445-4938-1-ND"
"","","C24",".022uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://product.tdk.com/info/en/catalog/datasheets/mlcc_comm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","0.10","C1005X7R1E223M050BB","Digi-key","445-4938-1-ND"
"","","C25",".1uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://product.tdk.com/info/en/catalog/datasheets/mlcc_comm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","0.11","GRM155R71H104KE14J","Digi-key","445-5932-1-ND"
"","","C26",".1uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://product.tdk.com/info/en/catalog/datasheets/mlcc_comm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","0.11","GRM155R71H104KE14J","Digi-key","445-5932-1-ND"
"","","C27",".1uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://product.tdk.com/info/en/catalog/datasheets/mlcc_comm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","0.11","GRM155R71H104KE14J","Digi-key","445-5932-1-ND"
"","","C28",".1uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://product.tdk.com/info/en/catalog/datasheets/mlcc_comm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","0.10","GRM155R71H104KE14J","Digi-key","490-13342-1-ND"
"","","C29",".1uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://product.tdk.com/info/en/catalog/datasheets/mlcc_comm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","0.11","GRM155R71H104KE14J","Digi-key","445-5932-1-ND"
"","","C30",".1uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://product.tdk.com/info/en/catalog/datasheets/mlcc_comm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","0.11","GRM155R71H104KE14J","Digi-key","445-5932-1-ND"
"","","C31",".1uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://product.tdk.com/info/en/catalog/datasheets/mlcc_comm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","0.11","GRM155R71H104KE14J","Digi-key","445-5932-1-ND"
"","","C32",".1uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://product.tdk.com/info/en/catalog/datasheets/mlcc_comm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","0.10","GRM155R71H104KE14J","Digi-key","490-13342-1-ND"
"","","C33",".022uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://product.tdk.com/info/en/catalog/datasheets/mlcc_comm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","0.10","C1005X7R1E223M050BB","Digi-key","445-4938-1-ND"
"","","C34",".022uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://product.tdk.com/info/en/catalog/datasheets/mlcc_comm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","0.10","C1005X7R1E223M050BB","Digi-key","445-4938-1-ND"
"","","C35",".022uF","Motor_Board-rescue:C_Small-Device","Motor_Board:C_0402_1005Metric_lines","https://product.tdk.com/info/en/catalog/datasheets/mlcc_comm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","0.10","C1005X7R1E223M050BB","Digi-key","445-4938-1-ND"
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
## KiCad design Debug-Chip-001/Debug-Chip-001.kicad_pcb

Parts:
P1: CONN_02X07; 2x7_pin_10in
P2, P3: CONN_01X07; Pin_Header_Straight_1x07_Pitch2.54mm

Connections:
unnamed: P1.1, P2.7
unnamed: P1.2, P3.1
unnamed: P1.3, P2.6
unnamed: P1.4, P3.2
unnamed: P1.5, P2.5
unnamed: P1.6, P3.3
unnamed: P1.7, P2.4
unnamed: P1.8, P3.4
unnamed: P1.9, P2.3
unnamed: P1.10, P3.5
unnamed: P1.11, P2.2
unnamed: P1.12, P3.6
unnamed: P1.13, P2.1
unnamed: P1.14, P3.7

Board: 2 copper layers, 58.4 x 27.9 mm, 3 parts (0 on the bottom side), 14 nets.

## KiCad design RS485/RS485.kicad_pcb

Board: 4 copper layers, 33.0 x 22.9 mm, 18 parts (0 on the bottom side), 17 nets.

Parts:
C1, C2: .1uF; C_0402
C3, C4, C5, C6, C7: C; C_0402
P1, P2: CONN_01X09; 9_pin_10in
R1, R2, R3, R4: 10k; R_0402
U1, U2, U4, U5: SP3485CN; SO-8
U3: TLV1117LV33DCYR

Connections:
+3V3: C1.1, C3.1, C4.1, C5.1, C6.1, C7.1, U1.8, U2.8, U3.2, U3.Tab, U4.8, U5.8
+5V: C2.1, P1.8, U3.3
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, P1.1, P1.9, P2.1, R1.2, R2.2, R3.2, R4.1, U1.2, U1.5, U2.2, U2.5, U3.1, U4.2, U4.5, U5.2, U5.5
unnamed: P1.2, U1.4
unnamed: P1.3, U1.1
unnamed: P1.4, R1.1, U1.3
unnamed: P1.5, U2.4
unnamed: P1.6, U2.1
unnamed: P1.7, R4.2, U2.3
unnamed: P2.2, U4.4
unnamed: P2.3, U4.1
unnamed: P2.4, R2.1, U4.3
unnamed: P2.5, U5.4
unnamed: P2.6, U5.1
unnamed: P2.7, R3.1, U5.3
unnamed: P2.8, U1.6, U2.6, U4.6, U5.6
unnamed: P2.9, U1.7, U2.7, U4.7, U5.7

## KiCad design AUX/Auxiliary_Board.kicad_pcb

Board: 4 copper layers, 152.4 x 152.4 mm, 24 parts (0 on the bottom side), 116 nets.

Parts:
C1: 10 uF; FK18X5R0J105K
GND_M1, GND_M2, GND_M3: CONN_01X10; 10pin_tenth_in
J1: CONN_01X16; 1723162216
J2: 2xDB9; DB9FC
J3: CONN_01X03; 2.1mm_DC_Jack
JP1, JP2, JP3: JUMPER; JPR_SHORT
M1, M2, M3: CONN_02X25; 50_pin_10in
M4: CONN_02X09; 2x_9_pin_10in
P1, P2, P3, P4, P5, P6: CONN_02X08; 2x8_conn_10in
PWR_M1, PWR_M2, PWR_M3: CONN_01X10; 10pin_tenth_in
U1: CONN_02X12; 24_pin_10in

Connections:
+5V: J1.15, M1.46, M1.48, M2.46, M2.48, M3.46, M3.48, M4.15, U1.2
+24V: J3.1, JP1.1, JP2.1, JP3.1
/A: J2.2, J2.11, M4.16
/B: J2.3, J2.12, M4.18
/BLANK: M1.42, M2.42, M3.42, U1.14
/GSCLK: M1.39, M2.39, M3.39, U1.9
/M1_SOUT: M1.47, M2.45
/M2_SOUT: M2.47, M3.45
/M3_SOUT: M3.47, U1.17
/PUMP+00: M1.5, P1.1
/PUMP+01: M1.6, P1.3
/PUMP+02: M1.9, P1.5
/PUMP+03: M1.10, P1.7
/PUMP+04: M1.13, P1.9
/PUMP+05: M1.14, P1.11
/PUMP+06: M1.17, P1.13
/PUMP+07: M1.18, P1.15
/PUMP+08: M1.23, P2.1
/PUMP+09: M1.24, P2.3
/PUMP+10: M1.27, P2.5
/PUMP+11: M1.28, P2.7
/PUMP+12: M1.31, P2.9
/PUMP+13: M1.32, P2.11
/PUMP+14: M1.35, P2.13
/PUMP+15: M1.36, P2.15
/PUMP+16: M2.5, P3.1
/PUMP+17: M2.6, P3.3
/PUMP+18: M2.9, P3.5
/PUMP+19: M2.10, P3.7
/PUMP+20: M2.13, P3.9
/PUMP+21: M2.14, P3.11
/PUMP+22: M2.17, P3.13
/PUMP+23: M2.18, P3.15
/PUMP+24: M2.23, P4.1
/PUMP+25: M2.24, P4.3
/PUMP+26: M2.27, P4.5
/PUMP+27: M2.28, P4.7
/PUMP+28: M2.31, P4.9
/PUMP+29: M2.32, P4.11
/PUMP+30: M2.35, P4.13
/PUMP+31: M2.36, P4.15
/PUMP+32: M3.5, P5.1
/PUMP+33: M3.6, P5.3
/PUMP+34: M3.9, P5.5
/PUMP+35: M3.10, P5.7
/PUMP+36: M3.13, P5.9
/PUMP+37: M3.14, P5.11
/PUMP+38: M3.17, P5.13
/PUMP+39: M3.18, P5.15
/PUMP+40: M3.23, P6.1
/PUMP+41: M3.24, P6.3
/PUMP+42: M3.27, P6.5
/PUMP+43: M3.28, P6.7
/PUMP+44: M3.31, P6.9
/PUMP+45: M3.32, P6.11
/PUMP+46: M3.35, P6.13
/PUMP+47: M3.36, P6.15
/PUMP-00: M1.3, P1.2
/PUMP-01: M1.4, P1.4
/PUMP-02: M1.7, P1.6
/PUMP-03: M1.8, P1.8
/PUMP-04: M1.11, P1.10
/PUMP-05: M1.12, P1.12
/PUMP-06: M1.15, P1.14
/PUMP-07: M1.16, P1.16
/PUMP-08: M1.21, P2.2
/PUMP-09: M1.22, P2.4
/PUMP-10: M1.25, P2.6
/PUMP-11: M1.26, P2.8
/PUMP-12: M1.29, P2.10
/PUMP-13: M1.30, P2.12
/PUMP-14: M1.33, P2.14
/PUMP-15: M1.34, P2.16
/PUMP-16: M2.3, P3.2
/PUMP-17: M2.4, P3.4
/PUMP-18: M2.7, P3.6
/PUMP-19: M2.8, P3.8
/PUMP-20: M2.11, P3.10
/PUMP-21: M2.12, P3.12
/PUMP-22: M2.15, P3.14
/PUMP-23: M2.16, P3.16
/PUMP-24: M2.21, P4.2
/PUMP-25: M2.22, P4.4
/PUMP-26: M2.25, P4.6
/PUMP-27: M2.26, P4.8
/PUMP-28: M2.29, P4.10
/PUMP-29: M2.30, P4.12
/PUMP-30: M2.33, P4.14
/PUMP-31: M2.34, P4.16
/PUMP-32: M3.3, P5.2
/PUMP-33: M3.4, P5.4
/PUMP-34: M3.7, P5.6
/PUMP-35: M3.8, P5.8
/PUMP-36: M3.11, P5.10
/PUMP-37: M3.12, P5.12
/PUMP-38: M3.15, P5.14
/PUMP-39: M3.16, P5.16
/PUMP-40: M3.21, P6.2
/PUMP-41: M3.22, P6.4
/PUMP-42: M3.25, P6.6
/PUMP-43: M3.26, P6.8
/PUMP-44: M3.29, P6.10
/PUMP-45: M3.30, P6.12
/PUMP-46: M3.33, P6.14
/PUMP-47: M3.34, P6.16
/PWR1: J1.5, JP1.2, PWR_M1.1, PWR_M1.2, PWR_M1.3, PWR_M1.4, PWR_M1.5, PWR_M1.6, PWR_M1.7, PWR_M1.8, PWR_M1.9, PWR_M1.10
/PWR2: J1.3, JP2.2, PWR_M2.1, PWR_M2.2, PWR_M2.3, PWR_M2.4, PWR_M2.5, PWR_M2.6, PWR_M2.7, PWR_M2.8, PWR_M2.9, PWR_M2.10
/PWR3: J1.1, JP3.2, PWR_M3.1, PWR_M3.2, PWR_M3.3, PWR_M3.4, PWR_M3.5, PWR_M3.6, PWR_M3.7, PWR_M3.8, PWR_M3.9, PWR_M3.10
/SCLK: M1.43, M2.43, M3.43, U1.13
/SIN: M1.45, U1.15
/UC_D12: M4.7, U1.20
/UC_NRST: C1.1, U1.5
/UC_RX: M4.5, U1.3
/UC_TX: M4.3, U1.1
/XLAT: M1.41, M2.41, M3.41, U1.11
GND: C1.2, GND_M1.1, GND_M1.2, GND_M1.3, GND_M1.4, GND_M1.5, GND_M1.6, GND_M1.7, GND_M1.8, GND_M1.9, GND_M1.10, GND_M2.1, GND_M2.2, GND_M2.3, GND_M2.4, GND_M2.5, GND_M2.6, GND_M2.7, GND_M2.8, GND_M2.9, GND_M2.10, GND_M3.1, GND_M3.2, GND_M3.3, GND_M3.4, GND_M3.5, GND_M3.6, GND_M3.7, GND_M3.8, GND_M3.9, GND_M3.10, J1.2, J1.4, J1.6, J1.8, J1.10, J1.12, J1.14, J1.16, J2.5, J2.10, J3.2, J3.3, M1.1, M1.2, M1.19, M1.20, M1.37, M1.38, M1.49, M1.50, M2.1, M2.2, M2.19, M2.20, M2.37, M2.38, M2.49, M2.50, M3.1, M3.2, M3.19, M3.20, M3.37, M3.38, M3.49, M3.50, M4.1, M4.2, M4.17, U1.4, U1.7
